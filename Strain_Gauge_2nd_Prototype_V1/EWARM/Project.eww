<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Strain_Gauge_2nd_Prototype.ewp</path>
  </project>
  <batchBuild />
</workspace>
